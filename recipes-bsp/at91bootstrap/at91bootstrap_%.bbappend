FILESEXTRAPATHS_prepend := "${THISDIR}/patches:"

SRC_URI += "file://sama5d3_xplainednf_uboot_defconfig.patch;patch=1"
